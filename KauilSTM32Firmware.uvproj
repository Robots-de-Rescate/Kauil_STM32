# Keil uVision project KauilSTM32Firmware.uvproj, settings and files
target KauilSTM32 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Kauil +hex
  c flags: Optim=1
  c include: .\Source;.\Source\STM32F30x_StdPeriph_Driver\inc;.\Source\STM32_USB-FS-Device_Driver\inc;.\Source\USB_ApplicationInterface;.\Source\Orientation;.\Source\ROS_USB;.\Source\Timers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group STM32F3_System
    ./Source/: main.c stm32f30x_it.c system_stm32f30x.c startup_stm32f30x.s
  group USB_ST_Driver
    ./Source/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Orientation
    ./Source/Orientation/: stm32f3_discovery_lsm303dlhc.c imu_util.c KalmanAHRS.c MadgwickFullAHRS.c stm32f3_discovery.c stm32f3_discovery_l3gd20.c orientation.c imu_devs.c
  group Misc
    ./Source/Misc/: delay.c
  group PeripheralDrivers
    ./Source/STM32F30x_StdPeriph_Driver/src/: stm32f30x_wwdg.c stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group USB_ApplicationInterface
    ./Source/USB_ApplicationInterface/: usb_pwr.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
  group ROS_USB
    ./Source/ROS_USB/: ROS_USB.c
  group Timers
    ./Source/Timers/: timers.c
